## src/drivers/uwb/uwb_crazyflie_px4/Kconfig
```kconfig
menuconfig DRIVERS_UWB_UWB_CFBOARD
	bool "uwb_cfboard"
	default n
	---help---
		Enable support for uwb cfboard
```
